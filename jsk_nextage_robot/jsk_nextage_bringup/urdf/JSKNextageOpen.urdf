Commit message: Update robot model

File: jsk_nextage_robot/jsk_nextage_bringup/urdf/JSKNextageOpen.urdf (robot description, URDF)
Before this commit: robot NextageOpen, 17 links, 16 joints
Links:
- link WAIST: mass 1000 -> None
